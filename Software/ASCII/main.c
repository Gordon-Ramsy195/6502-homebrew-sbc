#include <stdint.h>

// 6551 UART registers at $8400
#define UART_DATA    (*(volatile uint8_t *)0x8400)
#define UART_STATUS  (*(volatile uint8_t *)0x8401)
#define TDRE 0x10  // Transmitter Data Register Empty

// Send a single character
void uart_putchar(char c) {
    while ((UART_STATUS & TDRE) == 0);
    UART_DATA = c;
}

// Send a null-terminated string
void uart_puts(const char *str) {
    while (*str) {
        uart_putchar(*str++);
    }
}

const char *art[] = {
"   .......      ........................................ ...... ........        ........       ",
"  :#####:...  .....+####=...=####:...=###*....:*#%%%%%%#+:.....=#%%%%%%%*-....-##########+:    ",
"..:@@@@@#.........-@@@@@*...+@@@@:...*@@@%:..-@@@@@@@@@@@@-..:%@@@@@@@@@@@+...=@@@@@@@@@@@@+   ",
"..:@@@@@@=.......:%@@@@@*...+@@@@:...*@@@%:..*@@@%+++*@@@@*..=@@@@*+++%@@@@:..=@@@@#***#@@@@:  ",
"..:@@@@@@@:......*@@@@@@*.:.+@@@@:...*@@@%:..*@@@%-...=+++-..=@@@@-...+@@@@:..=@@@@:::.=@@@@:  ",
"..:@@@@@@@#.....-@@@@@@@*.:.+@@@@:...*@@@%:..=@@@@@#=:.......=@@@@-...+@@@@:..=@@@@-:::+@@@@:  ",
"..:@@@@@@@@=...:%@@@@@@@*.:.+@@@@:...*@@@%:...-#@@@@@%+:.....=@@@@-...+@@@@:..=@@@@@@@@@@@@#.  ",
"..:@@@@*@@@%:..+@@@##@@@*.:.+@@@@:...*@@@%:.....-*@@@@@@*:...=@@@@-...+@@@@:..=@@@@@@@@@@@*:.  ",
"..:@@@@=*@@@*:-@@@@-#@@@*.:.+@@@@:.:.*@@@%:.......:+%@@@@@-..=@@@@-...+@@@@:..=@@@@+%@@@%-...  ",
"..:@@@@=:%@@@+#@@@+:#@@@*...+@@@@:...*@@@%:..-===-..:-%@@@*..=@@@@-...+@@@@:..=@@@@=-%@@@#:..  ",
"..:@@@@=.=@@@@@@@%::#@@@*...+@@@@+===#@@@%:..#@@@%====%@@@*..=@@@@+===#@@@@:..=@@@@=.-%@@@#.   ",
"..:@@@@-..#@@@@@@-..#@@@*...-@@@@@@@@@@@@*...=@@@@@@@@@@@@=..:%@@@@@@@@@@@*...=@@@@-..-%@@@#.  ",
"  :%@@@-..:%@@@@+...*@@@+....-*%@@@@@@@#=.....-#%@@@@@@%#-....:*%@@@@@@@#=....=@@@@-...:%@@@#. ",
"  ..:::.....::::....::::........:::::::..........::::::..........:::::::............    .....  ",
"          .................................................................   .                ",
"            ...:==========-.....:===++++===-.......:=++++++=-.....-==========:.                ",
"            ...-@@@@@@@@@@@%-...=@@@@@@@@@@@%-....*@@@@@@@@@@#:...*@@@@@@@@@@@#:.              ",
"            ...-@@@@@@@@@@@@%:..=@@@@@@@@@@@@@:..+@@@@%%%%@@@@#...+@@@@@@@@@@@@#..             ",
"            ...-@@@@=:::+@@@@-..=@@@@=:::=@@@@-..+@@@@::::#@@@%...*@@@%-:::*@@@%..             ",
"            ...-@@@@=...=@@@@-..=@@@@-:::-@@@@-..+@@@%:...*@@@%:..*@@@%::::+@@@%..             ",
"            ...-@@@@=...=@@@@-..=@@@@#*#*#@@@@-..+@@@%:...*@@@%:..*@@@@#***%@@@%..             ",
"            ...-@@@@=...=@@@@-..=@@@@@@@@@@@@+...+@@@%:...*@@@%:..*@@@@@@@@@@@@-               ",
"            ...-@@@@=...=@@@@-..=@@@@#@@@@@+-....+@@@%:...*@@@%:..*@@@@%####*+:                ",
"            ...-@@@@=.:.=@@@@-..=@@@@==@@@@+.....+@@@%:...*@@@%:..*@@@@-....                   ",
"            ...-@@@@=:::+@@@@-..=@@@@+:=@@@@*....+@@@@-:::#@@@%...*@@@@:...                    ",
"            ...-@@@@@@@@@@@@%:..=@@@@=..=@@@@*...=@@@@@@@@@@@@#...+@@@@:..                     ",
"            ...-@@@@@@@@@@@%-...=@@@@=...=@@@@*...+@@@@@@@@@@#:...+@@@@:.                      ",
"             ...=++++++++=-.....:++++:....-++++:...:==+++++=:.....-====.                       ",
"              ..  .........................    ..........    ..                                ",
"                .......:........................ .  .....                       .              ",
"                     .=+: ...................                                  .-.             ",
"                    :=++=. ..................                                 .==              ",
"                   :+++++. ... ........ ... .                                .=+-              ",
"        :====-----=++++++: .. .......... ...                                :++=.              ",
"         :=++++++++++++++: .. :: .:. ..:.  ::                             :=+++-               ",
"          .-++++++++++++=.... --..-- . --. .=:                          :=++++=.               ",
"           -===+++++++++-.  . -=. -=.. :+:  -+:                      .-=+++++=.                ",
"          .....:-==++++++=-...==..-+:  :+=. .==.                ..:-=+++++++=.                 ",
"                 ...:=++++++==+- .=+-  :+=. .=+-    .:. ....::--=++++++++++=.                  ",
"               ..    .:=+++++++=--=+-  :++:  -+=. .-=+: -+=++++++++++++++=-.                   ",
"              ....   ..-===+++++++++=--=++-..-++--=+++=..-++++++++++++++=.                     ",
"                  ..:==-...=+=+++++++++++++++++++++++++=:..--==+++++++=:                       ",
"                ..:::..  .==-.:-=++++++++++++++++++++++++=-:...:=++=-:                         ",
"                ..      :==... .=+=:-=+++====+++===++++++++=: :===:.                           ",
"                  ... .--:. ...=+=.  -++-....=+=. .::-=++++: :-:.                              ",
"                  ....... .. .=+-...:++=. . :++-      ..:-=.                                   ",
"                  .... .....:==:...:=+-.....=+=. .        ..                                   ",
"           ................:=:....:==:.... :+=: ......                                         ",
"           ...............::.....:=-.......==: ......                                          ",
"           .....................:-........-=. .......                                          ",
"           ..............................:-. .........                                         ",
"           ...........................................                                         ",
};

#define ART_LINES (sizeof(art) / sizeof(art[0]))

// Jump to ROM monitor at $a000
void jump_to_rom(void) {
    __asm__("jmp $a000");
}

void main(void) {
    uint16_t i;
    
    uart_puts("\r\n");
    
    for (i = 0; i < ART_LINES; i++) {
        uart_puts(art[i]);
        uart_puts("\r\n");
    }
    
    uart_puts("\r\nDone!\r\n");
    
    jump_to_rom();
}
